options:
  parameters:
    author: OE1KBC
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: LIME TRX
  states: {}

blocks:
- name: enable_tone
  id: variable_qtgui_chooser
  parameters:
    label: TONE/MIC Chooser
    label0: Send 1750Hz Tone
    label1: Send with Mic
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequenz
    min_len: '20'
    start: '434000000'
    step: '12500'
    stop: '436000000'
    value: '434550000'
    widget: eng_slider
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: ptt
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: PTT ON/OFF
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    min_len: '20'
    start: '0'
    step: '1'
    stop: '40'
    value: '30'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    min_len: '20'
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
    widget: dial
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '8000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '32000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '1750'
    offset: '0'
    phase: '0'
    samp_rate: '8000.0'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: Mikrofon
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: not enable_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: enable_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    alias: ptt
    const: ptt
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000000'
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: NBFM Signal
    showports: 'True'
    type: complex
    units: dBm
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '1000000'
    type: ccc
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: '2000000'
    center_freq: freq
    dev_args: driver=lime,soapy=0
    gain: rf_gain
    samp_rate: '1000000'
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
