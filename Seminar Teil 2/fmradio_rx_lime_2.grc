options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Frequency
    start: 80.1e6
    step: '100000'
    stop: 108.1e6
    value: '99900000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Rx Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    comment: |-
      Adjust this value to set the 
      bandwidth of the signal
    value: '5000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '25'
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: group member of pulse, pulse-access, and audio
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '99900000'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '16'
    type: ccc
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '0'
    center_freq: center_freq
    dev_args: driver=lime,soapy=0
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
